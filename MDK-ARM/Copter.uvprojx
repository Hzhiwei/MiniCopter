# Keil uVision project Copter.uvprojx, settings and files
target Copter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Copter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,EMPL,MPU6500,EMPL_TARGET_STM32F4
  c include: ../Inc;    ../Drivers/STM32F3xx_HAL_Driver/Inc;    ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;    ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;    ../Middlewares/Third_Party/FreeRTOS/Source/include;    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;    ../Drivers/CMSIS/Include;    ..\HardwareDriver\inc;    ..\task\inc;    ..\mpl\driver\include;    ..\mpl\driver\eMPL;    ..\mpl\driver\stm32L;    ..\mpl\eMPL-hal;    ..\mpl\mllite;    ..\mpl\mpl;    ..\task\inc
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group HardwareDriver
    ../HardwareDriver/src/: Algorithm.c IIC.c Motor.c mpu6500.c Flash.c Bluetooth.c
  group task
    ../task/src/: task_Control.c
  group Application/User
    ../Src/: main.c tim.c freertos.c usb.c usart.c stm32f3xx_hal_timebase_TIM.c stm32f3xx_hal_msp.c stm32f3xx_it.c gpio.c iwdg.c
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c queue.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_i2c.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_cortex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal.c stm32f3xx_hal_pcd.c stm32f3xx_hal_iwdg.c
  group mpl
    ../mpl/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../mpl/driver/stm32L/: log.c
    ../mpl/eMPL-hal/: eMPL_outputs.c
    ../mpl/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../mpl/mpl/: libmpllib.lib
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
